// wii_ext_crypto.c - Wii Extension Controller Encryption
//
// Cipher for Wii extension controller reports. The Wiimote (or Wii console)
// sends a 16-byte key to extension registers 0x40-0x4F after writing 0xAA
// to register 0xF0. All subsequent register reads are encrypted.
//
// The cipher is a per-byte substitution: each byte is transformed using
// two 8-entry tables (ft and sb) indexed by address % 8:
//
//   encrypted = (plaintext - ft[addr % 8]) ^ sb[addr % 8]
//
// The ft and sb tables are derived from the 16-byte key using two 256-byte
// S-box lookup tables that are properties of the Wii hardware.
//
// Algorithm and S-box data from Hector Martin (marcan)'s 2008 reverse
// engineering of the Wii, published on wiibrew.org and sci.crypt.
// These are discovered hardware constants, not creative works.
//
// References:
//   https://wiibrew.org/wiki/Wiimote/Extension_Controllers
//   https://sci.crypt.narkive.com/g1zYewWd/reverse-engineering-the-wiimote-s-encryption
//
// SPDX-License-Identifier: Apache-2.0

#include "wii_ext_crypto.h"
#include <stdio.h>
#include <string.h>

bool wii_ext_crypto_enabled = false;

// Encryption key tables (derived from the 16-byte key via S-box lookup)
static uint8_t ft[8];
static uint8_t sb[8];

// S-box lookup tables — hardware constants from the Wii's extension
// controller encryption, reverse-engineered by Hector Martin (marcan), 2008.
// These are first-party extension S-boxes (used by official controllers).

static const uint8_t sbox_a[256] = {
    0x01, 0xa0, 0xa9, 0x62, 0xd6, 0x3f, 0x85, 0xa7, 0xb6, 0xd4, 0xfa, 0x15, 0x66, 0x17, 0x09, 0xbd,
    0x5d, 0x14, 0x34, 0x26, 0x59, 0x72, 0x91, 0x54, 0x06, 0x4f, 0xf8, 0xb0, 0x5b, 0x74, 0x93, 0x99,
    0x8c, 0xf2, 0x45, 0xcd, 0xea, 0x4e, 0xad, 0x10, 0x4a, 0xe5, 0xca, 0xee, 0xdf, 0xc6, 0x6f, 0x9f,
    0x88, 0x8e, 0x02, 0xcc, 0x08, 0xa8, 0x77, 0x94, 0x6d, 0x21, 0xb1, 0x28, 0xe4, 0x39, 0x79, 0x96,
    0x60, 0x71, 0x81, 0x16, 0x2e, 0xe6, 0x78, 0xb9, 0xc4, 0x46, 0x9a, 0x42, 0xae, 0xb7, 0x7c, 0x43,
    0xb3, 0x22, 0x1a, 0x86, 0xc2, 0x32, 0x3d, 0x2d, 0x9c, 0xd2, 0x29, 0xe9, 0x63, 0x9b, 0xd1, 0x31,
    0x38, 0x5e, 0x1e, 0x36, 0x41, 0xbb, 0x03, 0x18, 0x2b, 0x3e, 0xbf, 0x68, 0x61, 0xfc, 0x52, 0xc0,
    0xde, 0xe0, 0x0a, 0x58, 0x13, 0x5a, 0x00, 0xbe, 0x1c, 0x90, 0x0e, 0x53, 0x12, 0xfd, 0xe2, 0x6e,
    0xba, 0xce, 0x24, 0x27, 0x44, 0x7f, 0x87, 0xa3, 0xa1, 0xd5, 0x50, 0x40, 0xe3, 0xf9, 0x83, 0xf7,
    0xc7, 0xa2, 0x35, 0xc8, 0xdb, 0x19, 0xab, 0x2f, 0x11, 0x25, 0xed, 0x33, 0x9e, 0x55, 0xe1, 0x48,
    0xaf, 0x73, 0x84, 0xda, 0x2a, 0xaa, 0x51, 0xeb, 0x9d, 0x95, 0xb2, 0xcb, 0xe7, 0x70, 0x80, 0xfe,
    0x4c, 0x65, 0x04, 0xef, 0xc5, 0xf1, 0xc3, 0x3a, 0xb4, 0xf5, 0x5f, 0x23, 0x89, 0xdd, 0x30, 0xa5,
    0x8b, 0xd3, 0xf6, 0xdc, 0x4d, 0x64, 0xd7, 0xf0, 0x8f, 0xec, 0x56, 0x37, 0x5c, 0xa4, 0x0d, 0x07,
    0x76, 0x8a, 0x2c, 0x0b, 0xb5, 0xd8, 0xc1, 0x1f, 0xe8, 0x3b, 0xf4, 0x4b, 0x1b, 0x47, 0x6c, 0x49,
    0x67, 0x7b, 0x92, 0xcf, 0x75, 0x7e, 0x20, 0xd9, 0x7d, 0x3c, 0x97, 0x7a, 0xd0, 0x05, 0x6b, 0x0f,
    0x1d, 0xfb, 0x82, 0x98, 0x57, 0x8d, 0xf3, 0x6a, 0xbc, 0xac, 0xc9, 0xa6, 0xff, 0xb8, 0x69, 0x0c,
};

static const uint8_t sbox_b[256] = {
    0x4c, 0x4d, 0x72, 0x07, 0x5a, 0x49, 0x33, 0x8d, 0xa2, 0xab, 0x46, 0x3d, 0x63, 0x0d, 0xa0, 0x97,
    0xff, 0xf0, 0xf5, 0xfa, 0xc0, 0xe9, 0xdb, 0x62, 0xe4, 0xe1, 0x74, 0x43, 0xdc, 0x86, 0x18, 0x29,
    0x37, 0xf4, 0x06, 0xe2, 0xed, 0x6f, 0x90, 0x48, 0x1e, 0x2d, 0x1d, 0xea, 0x73, 0x94, 0x54, 0xdf,
    0x25, 0xf6, 0x47, 0x27, 0xd9, 0x11, 0x77, 0xc9, 0x84, 0x1c, 0x5b, 0x5c, 0x51, 0x81, 0xa6, 0x22,
    0x3e, 0x24, 0x96, 0xc8, 0x8a, 0xec, 0x82, 0x7c, 0x09, 0xb8, 0x45, 0x4a, 0x57, 0xbb, 0x2f, 0x50,
    0x75, 0x8e, 0x61, 0x70, 0x8c, 0x6c, 0xaf, 0xd0, 0xfd, 0xb4, 0x1b, 0xae, 0xde, 0xfe, 0x3b, 0xb5,
    0x36, 0xbd, 0x55, 0x01, 0x0e, 0x9c, 0x41, 0x56, 0x5f, 0xb3, 0x26, 0x03, 0x83, 0xba, 0x13, 0x4b,
    0xca, 0xc5, 0x0a, 0xf8, 0x60, 0xa5, 0xb9, 0xc7, 0xc3, 0x98, 0x32, 0xfb, 0x12, 0xf9, 0xa7, 0x92,
    0xaa, 0x68, 0xf3, 0x78, 0x7e, 0x05, 0x20, 0x21, 0x02, 0xe8, 0xbf, 0xf2, 0xb0, 0x59, 0x8f, 0xd2,
    0xcb, 0x87, 0x65, 0x15, 0xf1, 0x1a, 0xb2, 0x30, 0xad, 0xee, 0x58, 0xa3, 0x8b, 0x66, 0x1f, 0x2c,
    0xd7, 0x5d, 0x19, 0x85, 0xa8, 0xe6, 0xd3, 0x6b, 0xa1, 0x0c, 0x91, 0x93, 0x6a, 0x5e, 0x0b, 0x79,
    0xe3, 0xdd, 0x00, 0x4f, 0x3c, 0x89, 0x6e, 0x71, 0x69, 0xa9, 0xac, 0x40, 0xe5, 0x99, 0x28, 0xc6,
    0x31, 0x4e, 0x7a, 0xcd, 0x08, 0x9e, 0x7d, 0xef, 0x17, 0xfc, 0x88, 0xd8, 0xa4, 0x6d, 0x44, 0x95,
    0xd1, 0xb7, 0xd4, 0x9b, 0xbe, 0x2a, 0x34, 0x64, 0x2b, 0xcf, 0x2e, 0xeb, 0x38, 0xce, 0x23, 0xe0,
    0x3a, 0x3f, 0xf7, 0x7b, 0x9f, 0x10, 0x53, 0xbc, 0x52, 0x67, 0x16, 0xe7, 0x80, 0x76, 0x04, 0xc4,
    0xb6, 0xc1, 0xc2, 0x7f, 0x9a, 0xda, 0xd5, 0x39, 0x42, 0x14, 0x9d, 0xb1, 0x0f, 0x35, 0xd6, 0xcc,
};

void wii_ext_crypto_init(const uint8_t key_data[16])
{
    // The 16-byte key is split:
    //   key[0-5]  = key_data[0x40-0x45] relative to reg base = key_data[0-5]
    //   rand[0-9] = key_data[0x46-0x4F] relative to reg base = key_data[6-15]
    const uint8_t* key  = &key_data[0];   // 6 bytes
    const uint8_t* rand = &key_data[6];   // 10 bytes

    // Derive ft (first transformation table) from S-box lookups
    ft[0] = sbox_a[key[4]]  ^ sbox_b[rand[3]];
    ft[1] = sbox_a[key[2]]  ^ sbox_b[rand[5]];
    ft[2] = sbox_a[key[5]]  ^ sbox_b[rand[7]];
    ft[3] = sbox_a[key[0]]  ^ sbox_b[rand[2]];
    ft[4] = sbox_a[key[1]]  ^ sbox_b[rand[4]];
    ft[5] = sbox_a[key[3]]  ^ sbox_b[rand[9]];
    ft[6] = sbox_a[rand[0]] ^ sbox_b[rand[6]];
    ft[7] = sbox_a[rand[1]] ^ sbox_b[rand[8]];

    // Derive sb (second transformation table) from S-box lookups
    sb[0] = sbox_a[key[0]]  ^ sbox_b[rand[1]];
    sb[1] = sbox_a[key[5]]  ^ sbox_b[rand[4]];
    sb[2] = sbox_a[key[3]]  ^ sbox_b[rand[0]];
    sb[3] = sbox_a[key[2]]  ^ sbox_b[rand[9]];
    sb[4] = sbox_a[key[4]]  ^ sbox_b[rand[7]];
    sb[5] = sbox_a[key[1]]  ^ sbox_b[rand[8]];
    sb[6] = sbox_a[rand[3]] ^ sbox_b[rand[5]];
    sb[7] = sbox_a[rand[2]] ^ sbox_b[rand[6]];

    wii_ext_crypto_enabled = true;
    printf("[wii_ext_crypto] Encryption enabled (ft=%02X%02X%02X%02X sb=%02X%02X%02X%02X)\n",
           ft[0], ft[1], ft[2], ft[3], sb[0], sb[1], sb[2], sb[3]);
}

void wii_ext_crypto_encrypt(uint8_t* data, uint8_t addr, uint8_t len)
{
    for (uint8_t i = 0; i < len; i++, addr++) {
        data[i] = (data[i] - ft[addr % 8]) ^ sb[addr % 8];
    }
}

void wii_ext_crypto_decrypt(uint8_t* data, uint8_t addr, uint8_t len)
{
    // Inverse of encrypt: plaintext = (ciphertext ^ sb) + ft
    for (uint8_t i = 0; i < len; i++, addr++) {
        data[i] = (data[i] ^ sb[addr % 8]) + ft[addr % 8];
    }
}

// ---- Self-test --------------------------------------------------------------
//
// Known-answer test using a key captured from a real Wii + Wiimote session
// and expected values computed independently against Dolphin's reference
// (see prior research). If any step fails, the bug is inside this file
// (S-box data, derivation formula, or encrypt loop). If all steps pass,
// the cipher is correct and any analog-stick issues are NOT a crypto bug.

static void wii_ext_crypto_print_diff(const char* label,
                                      const uint8_t* got,
                                      const uint8_t* want,
                                      size_t n)
{
    printf("[wii_ext_crypto]   %s got : ", label);
    for (size_t i = 0; i < n; i++) printf("%02X ", got[i]);
    printf("\n[wii_ext_crypto]   %s want: ", label);
    for (size_t i = 0; i < n; i++) printf("%02X ", want[i]);
    printf("\n");
}

void wii_ext_crypto_self_test(void)
{
    // Standalone self-test — computes everything in locals, never touches
    // the module's ft/sb/enabled state. Safe to call anywhere, including
    // from inside wii_ext_crypto_init just before the real init runs.
    static const uint8_t test_key[6]  = {0x39, 0x1B, 0x5B, 0x41, 0x15, 0x5E};
    static const uint8_t test_rand[10] = {
        0xDF, 0xCA, 0x39, 0x1B, 0x6E, 0xFE, 0x16, 0x16, 0x62, 0xC3
    };
    static const uint8_t expected_ft[8] = {
        0x31, 0x3F, 0x0A, 0x3D, 0xA3, 0xBC, 0x92, 0x03,
    };
    static const uint8_t expected_sb[8] = {
        0xA9, 0xC2, 0x91, 0x24, 0xA9, 0xE5, 0x66, 0xFA,
    };
    static const uint8_t cal_plain[16] = {
        0xFC, 0x04, 0x7E, 0xFC, 0x04, 0x7E, 0xFC, 0x04,
        0x7E, 0xFC, 0x04, 0x7E, 0x00, 0x00, 0x4D, 0xA2,
    };
    static const uint8_t cal_cipher_expected[16] = {
        0x62, 0x07, 0xE5, 0x9B, 0xC8, 0x27, 0x0C, 0xFB,
        0xE4, 0x7F, 0x6B, 0x65, 0xF4, 0xA1, 0xDD, 0x65,
    };
    static const uint8_t data_plain[6]  = { 0xA0, 0x20, 0x10, 0x00, 0xFF, 0xFF };
    static const uint8_t data_cipher_expected[6] = {
        0xC6, 0x23, 0x97, 0xE7, 0xF5, 0xA6,
    };

    const uint8_t* k = test_key;
    const uint8_t* r = test_rand;
    uint8_t lft[8], lsb[8];

    lft[0] = sbox_a[k[4]] ^ sbox_b[r[3]];
    lft[1] = sbox_a[k[2]] ^ sbox_b[r[5]];
    lft[2] = sbox_a[k[5]] ^ sbox_b[r[7]];
    lft[3] = sbox_a[k[0]] ^ sbox_b[r[2]];
    lft[4] = sbox_a[k[1]] ^ sbox_b[r[4]];
    lft[5] = sbox_a[k[3]] ^ sbox_b[r[9]];
    lft[6] = sbox_a[r[0]] ^ sbox_b[r[6]];
    lft[7] = sbox_a[r[1]] ^ sbox_b[r[8]];
    lsb[0] = sbox_a[k[0]] ^ sbox_b[r[1]];
    lsb[1] = sbox_a[k[5]] ^ sbox_b[r[4]];
    lsb[2] = sbox_a[k[3]] ^ sbox_b[r[0]];
    lsb[3] = sbox_a[k[2]] ^ sbox_b[r[9]];
    lsb[4] = sbox_a[k[4]] ^ sbox_b[r[7]];
    lsb[5] = sbox_a[k[1]] ^ sbox_b[r[8]];
    lsb[6] = sbox_a[r[3]] ^ sbox_b[r[5]];
    lsb[7] = sbox_a[r[2]] ^ sbox_b[r[6]];

    bool ft_ok = (memcmp(lft, expected_ft, 8) == 0);
    bool sb_ok = (memcmp(lsb, expected_sb, 8) == 0);

    uint8_t cal_buf[16];
    memcpy(cal_buf, cal_plain, 16);
    for (int i = 0; i < 16; i++) {
        uint8_t a = (uint8_t)(0x20 + i);
        cal_buf[i] = (cal_buf[i] - lft[a & 7]) ^ lsb[a & 7];
    }
    bool cal_ok = (memcmp(cal_buf, cal_cipher_expected, 16) == 0);

    uint8_t data_buf[6];
    memcpy(data_buf, data_plain, 6);
    for (int i = 0; i < 6; i++) {
        uint8_t a = (uint8_t)(0x00 + i);
        data_buf[i] = (data_buf[i] - lft[a & 7]) ^ lsb[a & 7];
    }
    bool data_ok = (memcmp(data_buf, data_cipher_expected, 6) == 0);

    printf("[wii_ext_crypto] selftest ft=%s sb=%s cal=%s data=%s (overall %s)\n",
           ft_ok ? "OK" : "BAD",
           sb_ok ? "OK" : "BAD",
           cal_ok ? "OK" : "BAD",
           data_ok ? "OK" : "BAD",
           (ft_ok && sb_ok && cal_ok && data_ok) ? "PASS" : "FAIL");
    if (!ft_ok)   wii_ext_crypto_print_diff("ft",   lft,      expected_ft, 8);
    if (!sb_ok)   wii_ext_crypto_print_diff("sb",   lsb,      expected_sb, 8);
    if (!cal_ok)  wii_ext_crypto_print_diff("cal",  cal_buf,  cal_cipher_expected, 16);
    if (!data_ok) wii_ext_crypto_print_diff("data", data_buf, data_cipher_expected, 6);
}
